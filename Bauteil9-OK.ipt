# Autodesk Inventor part: Bauteil9-OK
## iProperties
Created: 2005-06
Part Number: Bauteil9-OK
Document SubType Name: Modeling
Designer: M.Fiedler
Author: M.Fiedler
## Feature names
1. Extrusion1
